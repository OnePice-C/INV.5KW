# Repository OnePice-C/INV.5KW

## KiCad design Doc.Design.INV/Grid_Tie_Inverter_V5-main/PCB_Related/GTI_V5/GTI_V5.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C9, C10, C14, C18, C19, C24, C35, C39, C42, C43, C44, C45, C48, C51, C52, C57, C60, C62, C63, C65, C68, C69, C70: 100nF; C_0603_1608Metric
C5, C21: 0.47uF; C_2225_5664Metric
C7, C8, C23, C25, C37, C54, C55: 2.2uF; C_0603_1608Metric
C11, C31, C40, C46, C58, C66: 10nF; C_0603_1608Metric
C12, C13, C15, C26, C29, C30: 22pF; C_0603_1608Metric
C16, C17: 20pF; C_0603_1608Metric
C20: 2.2uF; C_Rect_L26.5mm_W11.5mm_P22.50mm_MKS4
C22, C27, C28: 2200pF; C901U222MZVDBA7317; Mouser Part Number 80-C901U222MZVDBAP
C32: 220uF; CP_Radial_D25.0mm_P10.00mm_SnapIn
C33: 2.2uF; C_Rect_L18.0mm_W11.0mm_P15.00mm_FKS3_FKP3
C34, C49, C50: 22uF; CAPPC3328X220N; Mouser Part Number 74-595D226X9020B2T
C36, C53, C61: 100pF; C_0603_1608Metric
C38, C41, C47, C56, C59, C64, C67, C71: 1uF; C_0603_1608Metric
C73: 4.7uF; C_0805_2012Metric
C74, C75: 10uF; C_0603_1608Metric
D1, D2, D3: SB05W05C-TB-E; SOT95P250X135-3N; Mouser Part Number 863-SB05W05C-TB-E
D4: LED; LED_0603_1608Metric
D5, D7, D10, D11: MSS1P4; D_MicroSMP
D6: ES1J; DIOM5227X250N
D8, D9: 512-ES1J; D_SMA
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
H5: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
IC3, IC7, IC8: MAX253CSA+; SOIC127P600X175-8N; Mouser Part Number 700-MAX253CSA
IC4, IC5, IC6, IC9: AMC1306M25QDWVRQ1; SOIC127P1150X280-8N; Mouser Part Number 595-MC1306M25QDWVRQ1
J1: Screw_Terminal_01x03; TerminalBlock_bornier-3_P5.08mm
J2, J3: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J4: Conn_01x05_Male; PinHeader_1x05_P1.27mm_Vertical
J5, J6: Conn_01x02_Male; PinHeader_1x02_P1.27mm_Vertical
K1, K2: G5LE-1; Relay_SPDT_Omron-G5LE-1
L1, L2: 1.5mH; L_Toroid_Vertical_L35.1mm_W21.1mm_P18.50mm_Vishay_TJ6
L4: 1mH; L_Toroid_Vertical_L41.9mm_W19.1mm_P15.80mm_Vishay_TJ7
L5: 744824622; WE-CMB_L5; Mouser Part Number 710-744824622
PS1, PS2, PS3: AP2210K-5.0TRG1; SOT95P282X130-5N; Mouser Part Number 621-AP2210K-5.0TRG1
Q1, Q3, Q4, Q5: BUZ11; TO-220-3_Vertical
Q2: 2N7002; SOT-23
R1, R34: 4.7R; R_0603_1608Metric
R2, R3, R38, R39, R40: 47R; R_0603_1608Metric
R5, R8, R9, R24, R25, R26: 470K; R_0805_2012Metric
R6, R15, R33, R35, R41, R44: 4.7K; R_0603_1608Metric
R7: 6.8R; R_2512_6332Metric
R10: 50mR; R_2512_6332Metric
R11, R18, R19, R21, R22, R31, R36, R42: 10R; R_0603_1608Metric
R12, R20, R27, R29: 1K; R_0603_1608Metric
R13, R32, R37, R43: 10K; R_0603_1608Metric
R14: 20mR; R_2512_6332Metric
R30: 2.2K; R_0603_1608Metric
T1, T2, T3: 760390014; 760390015; Mouser Part Number 710-760390014
U1: STM32L475RCTx; LQFP-64_10x10mm_P0.5mm
U2, U5: UCC21520ADW; SOIC-16W_7.5x10.3mm_P1.27mm
U3: AZ1117-5.0; AZ1117CD50TRG1
U4: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
Y1: Crystal_GND24; Crystal_SMD_Abracon_ABM10-4Pin_2.5x2.0mm

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C14.2, C18.2, C38.1, C39.1, C45.1, C56.1, C57.1, C59.1, C64.1, C65.1, C69.1, C70.1, C75.1, IC4.8 (DVDD), IC5.8 (DVDD), IC6.8 (DVDD), IC9.8 (DVDD), J4.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDDUSB), U1.64 (VDD), U2.3 (VCCI), U2.8 (VCCI), U4.2 (VO), U5.3 (VCCI), U5.8 (VCCI)
+5V: C43.1, C62.1, C63.1, C74.1, IC3.3 (FS), IC3.6 (VCC), IC7.3 (FS), IC7.6 (VCC), IC8.3 (FS), IC8.6 (VCC), T1.2, T2.2, T3.2, U3.2 (VO), U4.3 (VI)
+5VD: C37.1, C67.1, C68.1, IC9.1 (AVDD), PS1.5 (VOUT)
+5V_1: C41.1, C42.1, C47.1, C48.1, C54.1, IC4.1 (AVDD), IC5.1 (AVDD), PS2.5 (VOUT)
+5V_2: C55.1, C60.1, IC6.1 (AVDD), PS3.5 (VOUT)
+12V: C8.1, C9.2, C24.2, C25.1, C34.1, C35.1, C44.1, D1.3 (K), PS1.1 (VIN), PS1.3 (EN), R1.1, R34.2, U2.11 (VDDB), U5.11 (VDDB)
/Cap_Isense: C20.2, R10.1, R21.2
/Line_GND: C27.1, C41.2, C42.2, C47.2, C48.2, C49.2, C51.2, C53.2, C54.2, IC4.4 (AGND), IC5.4 (AGND), L5.9 (4), PS2.2 (GND), R12.2, R14.2, R19.2, R20.2, T2.5
/Line_Isense: K2.1, R14.1, R18.2
/Line_Vsense: C40.1, IC4.2 (INP), R9.2, R12.1
/NRST: C10.1, J4.5, U1.7 (NRST)
/Out_B: C50.2, C52.2, C55.2, C60.2, C61.2, IC6.4 (AGND), L1.2, L4.1, PS3.2 (GND), R10.2, R22.2, T3.5
/Relay: D6.1 (A), K1.2, K2.2, Q2.3 (D)
/Relay_Ctrl: Q2.1 (G), U1.44 (PA11)
/SWCLK: J4.2, U1.49 (PA14)
/SWDIO: J4.4, U1.46 (PA13)
/VDDA_A: C6.1, C7.1, D8.1 (K), U2.16 (VDDA)
/VDDA_B: C19.2, C23.1, D9.1 (K), U5.16 (VDDA)
CLK_SigmaDelta: IC4.7 (CLKIN), IC5.7 (CLKIN), IC6.7 (CLKIN), IC9.7 (CLKIN), U1.10 (PC2)
D1_Sigma_Delta: IC4.6 (DOUT), U1.35 (PB14)
D2_Sigma_Delta: IC5.6 (DOUT), U1.33 (PB12)
D3_Sigma_Delta: IC6.6 (DOUT), U1.38 (PC7)
D4_Sigma_Delta: IC9.6 (DOUT), U1.27 (PB1)
Earth: C22.1, C28.2, H5.1, J1.2
GND: C5.2, C8.2, C9.1, C21.2, C24.1, C25.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C44.2, C67.2, C68.2, IC9.4 (AGND), J3.2, PS1.2 (GND), Q3.3 (S), Q5.3 (S), R27.2, R29.2, R32.1, R43.1, T1.5, U2.9 (VSSB), U5.9 (VSSB)
GNDD: C1.2, C2.2, C3.2, C4.2, C10.2, C11.1, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.1, C26.2, C29.2, C30.2, C31.1, C38.2, C39.2, C43.2, C45.2, C56.2, C57.2, C59.2, C62.2, C63.2, C64.2, C65.2, C69.2, C70.2, C71.2, C73.2, C74.2, C75.2, D4.1 (K), IC3.2 (GND1), IC3.4 (SD), IC3.7 (GND2), IC4.5 (DGND), IC5.5 (DGND), IC6.5 (DGND), IC7.2 (GND1), IC7.4 (SD), IC7.7 (GND2), IC8.2 (GND1), IC8.4 (SD), IC8.7 (GND2), IC9.5 (DGND), J2.1, J4.3, J5.1, J6.1, Q2.2 (S), R33.1, R44.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.60 (BOOT0), U1.63 (VSS), U2.4 (GND), U3.1 (GND), U4.1 (GND), U5.4 (GND), Y1.2, Y1.4
unnamed: C6.2, C7.2, L2.1, Q1.3 (S), Q3.2 (D), R13.1, U2.14 (VSSA)
unnamed: C11.2, R33.2, U2.6 (DT)
unnamed: C12.1, C26.1, R40.2, U2.5 (DIS), U5.5 (DIS)
unnamed: C13.1, R2.2, U2.1 (INA)
unnamed: C15.1, R3.2, U2.2 (INB)
unnamed: C16.1, U1.6 (PH1), Y1.1
unnamed: C17.1, U1.5 (PH0), Y1.3
unnamed: C19.1, C23.2, L1.1, Q4.3 (S), Q5.2 (D), R37.1, U5.14 (VSSA)
unnamed: C20.1, R7.2
unnamed: C22.2, J1.3, L5.4 (1)
unnamed: C27.2, K1.1, L5.7 (2), R5.1
unnamed: C28.1, J1.1, L5.2 (3)
unnamed: C29.1, R38.2, U5.1 (INA)
unnamed: C30.1, R39.2, U5.2 (INB)
unnamed: C31.2, R44.2, U5.6 (DT)
unnamed: C36.1, PS1.4 (BYP)
unnamed: C40.2, IC4.3 (INN), R20.1
unnamed: C46.1, IC5.2 (INP), R18.1
unnamed: C46.2, IC5.3 (INN), R19.1
unnamed: C49.1, C51.1, D2.3 (K), PS2.1 (VIN), PS2.3 (EN)
unnamed: C50.1, C52.1, D3.3 (K), PS3.1 (VIN), PS3.3 (EN)
unnamed: C53.1, PS2.4 (BYP)
unnamed: C58.1, IC6.2 (INP), R21.1
unnamed: C58.2, IC6.3 (INN), R22.1
unnamed: C61.1, PS3.4 (BYP)
unnamed: C66.1, IC9.2 (INP), R24.2, R27.1
unnamed: C66.2, IC9.3 (INN), R29.1
unnamed: D1.1 (A_1), T1.6
unnamed: D1.2 (A_2), T1.4
unnamed: D2.1 (A_1), T2.6
unnamed: D2.2 (A_2), T2.4
unnamed: D3.1 (A_1), T3.6
unnamed: D3.2 (A_2), T3.4
unnamed: D4.2 (A), R30.2
unnamed: D5.1 (K), R6.2
unnamed: D5.2 (A), Q1.1 (G), R11.1, R13.2
unnamed: D7.1 (K), R15.2
unnamed: D7.2 (A), Q3.1 (G), R31.1, R32.2
unnamed: D8.2 (A), R1.2
unnamed: D9.2 (A), R34.1
unnamed: D10.1 (K), R35.2
unnamed: D10.2 (A), Q4.1 (G), R36.1, R37.2
unnamed: D11.1 (K), R41.2
unnamed: D11.2 (A), Q5.1 (G), R42.1, R43.2
unnamed: IC3.1 (D1), T1.1
unnamed: IC3.8 (D2), T1.3
unnamed: IC7.1 (D1), T2.1
unnamed: IC7.8 (D2), T2.3
unnamed: IC8.1 (D1), T3.1
unnamed: IC8.8 (D2), T3.3
unnamed: J5.2, U1.21 (PA5)
unnamed: J6.2, U1.58 (PB6)
unnamed: K1.3, L2.2, R7.1
unnamed: K2.3, L4.2
unnamed: R5.2, R8.1
unnamed: R8.2, R9.1
unnamed: R6.1, R11.2, U2.15 (OUTA)
unnamed: R15.1, R31.2, U2.10 (OUTB)
unnamed: R24.1, R25.2
unnamed: R25.1, R26.2
unnamed: R30.1, U1.15 (PA1)
unnamed: R35.1, R36.2, U5.15 (OUTA)
unnamed: R41.1, R42.2, U5.10 (OUTB)
PWM_A_H: R2.1, U1.41 (PA8)
PWM_A_L: R3.1, U1.23 (PA7)
PWM_B_H: R38.1, U1.42 (PA9)
PWM_B_L: R39.1, U1.26 (PB0)
PWM_Disable: R40.1, U1.16 (PA2)
VBUS: C5.1, C21.1, C32.1, C33.1, J3.1, Q1.2 (D), Q4.2 (D), R26.1
VCC: C71.1, C73.1, D6.2 (K), J2.2, K1.5, K2.5, U3.3 (VI)

Board: 4 copper layers, 155.0 x 75.0 mm, 165 parts (24 on the bottom side), 96 nets.

## Code that names these connections

File Doc.Design.INV.OFG/Grid_Tie_Inverter_V5-main/STM32CubeIDE_Code/GTI_v5.ioc (part):

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Mcu.Name=STM32L475R(C-E-G)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32L475RCTx
PA1.GPIOParameters=GPIO_Speed,GPIO_Label
PA1.GPIO_Label=LED
PA1.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PA1.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_Speed,GPIO_Label
PA11.GPIO_Label=Relay
PA11.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PA11.Signal=GPIO_Output
PA2.GPIOParameters=GPIO_Speed,PinState,GPIO_Label
PA2.GPIO_Label=Driver_Disable
PA2.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PA2.PinState=GPIO_PIN_SET
PA2.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=DAC_Out
PA5.Signal=COMP_DAC12_group
PA7.GPIOParameters=GPIO_Speed,GPIO_Label
PA7.GPIO_Label=PWM_A_L
PA7.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA7.Mode=PWM Generation1 CH1 CH1N
PA7.Signal=TIM1_CH1N
PA8.GPIOParameters=GPIO_Speed,GPIO_Label
PA8.GPIO_Label=PWM_A_H
PA8.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA8.Signal=S_TIM1_CH1
PA9.GPIOParameters=GPIO_Speed,GPIO_Label
PA9.GPIO_Label=PWM_B_H
PA9.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA9.Signal=S_TIM1_CH2
PB0.GPIOParameters=GPIO_Speed,GPIO_Label
PB0.GPIO_Label=PWM_B_L
PB0.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB0.Mode=PWM Generation2 CH2 CH2N
PB0.Signal=TIM1_CH2N
PB1.GPIOParameters=GPIO_Speed,GPIO_Label
PB1.GPIO_Label=Vbus_DIN
PB1.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB1.Signal=S_DATAIN0DFSDM1
PB12.GPIOParameters=GPIO_Speed,GPIO_Label
PB12.GPIO_Label=Igrid_DIN
PB12.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB12.Signal=S_DATAIN1DFSDM1
PB14.GPIOParameters=GPIO_Speed,GPIO_Label
PB14.GPIO_Label=Vgrid_DIN
PB14.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB14.Signal=S_DATAIN2DFSDM1
PC2.GPIOParameters=GPIO_Speed,GPIO_Label
PC2.GPIO_Label=DFSDM_Clk
PC2.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PC2.Signal=S_CKOUTDFSDM1
PC7.GPIOParameters=GPIO_Speed,GPIO_Label
PC7.GPIO_Label=Icap_DIN
PC7.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PC7.Signal=S_DATAIN3DFSDM1
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=80000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2025-06-30 push trip zone
